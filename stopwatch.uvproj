# Keil uVision project stopwatch.uvproj, settings and files
target stopwatch (MCS-51)
  device: STC8F2K64S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: stopwatch +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./src/: serial.c utility.c stopwatch.c scroll.c alarm.c systimer.c keyprocess.c ds1302.c eeprom.c voltage.c lcd.c
  group h
    ./h/: serial.h utility.h scroll.h led.h stopwatch.h alarm.h ds1302.h systimer.h keyprocess.h eeprom.h port.h voltage.h
